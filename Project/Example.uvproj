# Keil uVision project Example.uvproj, settings and files
target Uxample (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103RC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Uxample +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\GD32\STM32F10x;..\Libraries\GD32F10x_StdPeriph_Driver\inc;..\Libraries\USBlibrary\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c usart1.c delay.c
  group GD32F1x0_StdPeriph_Driver
    ../Libraries/GD32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c misc.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/GD32/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/GD32/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
